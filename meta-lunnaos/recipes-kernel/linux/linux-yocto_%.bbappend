# LunnaOS keeps the upstream Linux/Yocto kernel recipe and only brands the build.
KERNEL_LOCALVERSION:append = "-lunnaos"
