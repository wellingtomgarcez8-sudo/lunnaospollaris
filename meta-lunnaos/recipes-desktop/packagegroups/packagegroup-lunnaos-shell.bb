SUMMARY = "LunnaOS desktop shell, applications and integration"
LICENSE = "MIT"
inherit packagegroup
RDEPENDS:${PN} = "lunnaos-shell lunnaos-defaults lunnaos-platform"